# Keil uVision project c8t6_control_mecanum.uvprojx, settings and files
target STM32F103C8T6 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: c8t6_control_mecanum +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xB
  c include: .\Core;.\Drivers;.\App
  asm include: .\Core;.\Drivers;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    Startup/: startup_stm32f103c8tx.s
  group Core
    Core/: main.c system_stm32f10x.c
  group Drivers
    Drivers/: gpio.c led.c oled.c systick.c pwm.c tb6612.c encoder.c ps2.c
  group App
    App/: mecanum.c pid.c control.c
